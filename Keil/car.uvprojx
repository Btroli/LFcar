# Keil uVision project car.uvprojx, settings and files
target CAR (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: car
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: ..\C\system\Libraries\CMSIS;..\C\system\Libraries\Driver\inc;..\C\system\ELSE;..\C\USER_h
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group CMSIS
    ../C/system/Libraries/CMSIS/: core_cm3.c system_stm32f10x.c
  group STARTUP
    ../C/system/Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group FWLB
    ../C/system/Libraries/Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group ELSE_h
    ../C/system/ELSE/: stm32f10x_it.c
  group USER_h
    ../C/USER_h/: delay.c LightSensor.c pwm.c sys.c encoder.c oled.c button.c key.c
  group MAIN
    ../C/: main.c
